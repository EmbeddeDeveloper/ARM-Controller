# Keil uVision project vibes_log.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: vibes_log +hex
  c flags: Optim=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s config.h main.c mmaspi.c mmaspi.h spi0.c spi0.h uart.c uart.h clcd.c clcd.h
